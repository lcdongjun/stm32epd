# Keil uVision project boot.uvprojx, settings and files
target BOOT (5040049::V5.04 update 1 (build 49)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: BOOT +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\at_command;..\SYSTEM\update;..\USER;..\FWLIB\src;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\SPI;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\FWLIB\DSP_Lib\Include;..\FWLIB\DSP_Lib\Source\FastMathFunctions;..\FWLIB\DSP_Lib\Source\CommonTables;..\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/at_command/: at_command.c
    ../SYSTEM/update/: update.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group README
    ../: readme.txt
  group DSP_Lib
    ../FWLIB/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../FWLIB/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
  group malloc
    ../MALLOC/: malloc.c
